Commit message: adding some extra features

File: build/lib/simple_driving/resources/simpleplane.urdf (robot description, URDF)
Before this commit: robot simpleplane, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=20 20 0.01; visual box size=20 20 0.01
